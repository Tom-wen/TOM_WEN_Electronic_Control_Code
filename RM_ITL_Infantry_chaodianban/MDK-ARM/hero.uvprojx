# Keil uVision project hero.uvprojx, settings and files
target hero (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: hero +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\application;..\application\protocol;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\Hardware\Inc;..\User\Inc;..\boards;..\Task;..\components\algorithm;..\components\algorithm\Include;..\components\controller;..\components\devices;..\components\support;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Hardware\Inc
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./: startup_stm32f407xx.s
  group User
    ../User/Src/: main.c freertos.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../User/Inc/: config.h
  group Task
    ../Task/: chassis_task.c gimbal_task.c shoot_task.c referee_usart_task.c detect_task.c INS_task.c
  group Hardware
    ../Hardware/Src/: adc.c can.c crc.c dma.c gpio.c i2c.c rng.c rtc.c spi.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_desc.c usbd_conf.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group applications
    ../application/: chassis_behaviour.c chassis_power_control.c remote_control.c gimbal_behaviour.c referee.c CAN_receive.c USART_receive.c custom_ui_draw.c
  group algorithm
    ../components/algorithm/: AHRS_middleware.c user_lib.c AHRS.lib arm_cortexM4lf_math.lib
  group controller
    ../components/controller/: filter.c fsm.c pid.c
  group support
    ../components/support/: CRC8_CRC16.c fifo.c mem_mang4.c
  group devices
    ../components/devices/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group boards
    ../boards/: bsp_adc.c bsp_buzzer.c bsp_can.c bsp_crc32.c bsp_delay.c bsp_flash.c bsp_i2c.c bsp_imu_pwm.c bsp_laser.c bsp_led.c bsp_rc.c bsp_rng.c bsp_servo_pwm.c bsp_spi.c bsp_usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../User/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ReadMe
    ../ReadMe/: ReadMe.txt
    ./: dailiy_record.txt
