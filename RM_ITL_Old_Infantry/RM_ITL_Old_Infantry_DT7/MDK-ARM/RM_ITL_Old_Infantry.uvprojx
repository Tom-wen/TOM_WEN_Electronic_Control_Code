# Keil uVision project RM_ITL_Old_Infantry.uvprojx, settings and files
target RM_ITL_Old_Infantry (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RM_ITL_Old_Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Task;../application;../boards;../components/support;../components/devices;../components/controller;../components/algorithm;../components/devices/BMI088/inc;../components/devices/BMI088;../components/CRC;../components/control_power;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/DSP/Include/dsp;../Middlewares/ST/ARM/DSP/Inc;../components/Circular_buffer;../components/UI
  asm include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Task
    ../Task/: chassis_task.c chassis_task.h detect_task.c detect_task.h gimbal_task.c gimbal_task.h INS_task.c INS_task.h referee_usart_task.c referee_usart_task.h shoot_task.c shoot_task.h hoisting_task.c hoisting_task.h
  group boards
    ../boards/: bsp_can.c bsp_can.h bsp_delay.c bsp_delay.h bsp_imu_pwm.c bsp_imu_pwm.h bsp_usart.c bsp_usart.h bsp_dwt.c bsp_dwt.h bsp_pwm.c bsp_pwm.h bsp_led.c bsp_led.h bsp_buzzer.c bsp_buzzer.h
  group components
    ../components/devices/BMI088/: BMI088driver.c BMI088Middleware.c
    ../components/devices/BMI088/inc/: BMI088driver.h BMI088Middleware.h BMI088reg.h
    ../components/algorithm/: user_lib.c user_lib.h arm_cortexM4lf_math.lib controller.c controller.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
    ../components/devices/: MahonyAHRS.h
    ../components/controller/: pid.c pid.h
    ../components/CRC/: CRC.c CRC.h
    ../components/Circular_buffer/: Circular_buffer.c Circular_buffer.h
    ../components/UI/: ui.h ui_default.c ui_default.h ui_dynamic_ui.c ui_dynamic_ui.h ui_interface.c ui_interface.h ui_static_ui.c ui_static_ui.h ui_types.h
  group application
    ../application/: CAN_receive.c CAN_receive.h remote_control.c remote_control.h struct_typedef.h chassis_behaviour.c chassis_behaviour.h gimbal_behaviour.c gimbal_behaviour.h USART_receive.c USART_receive.h GQ_Motor.c GQ_Motor.h control_power.c control_power.h
software components: CMSIS:CORE 4.3.0
